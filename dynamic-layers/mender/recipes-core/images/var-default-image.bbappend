# Bring in Mender explicit WIC layout and image additions.
require mender-explicit-wic-image.inc
