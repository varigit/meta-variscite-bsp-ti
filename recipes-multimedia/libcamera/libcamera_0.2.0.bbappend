# Add missing dependency
DEPENDS += "openssl"
