## conf/machine/variscite_bcm43xx.inc
```bitbake
MACHINE_ESSENTIAL_EXTRA_RDEPENDS += " \
	linux-firmware-bcm4339 \
	linux-firmware-bcm43430 \
"
```
