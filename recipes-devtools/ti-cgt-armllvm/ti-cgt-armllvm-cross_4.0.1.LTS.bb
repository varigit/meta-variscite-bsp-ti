require ti-cgt-armllvm-cross.inc

TOOLCHAIN_BIN = "ti_cgt_armllvm_4.0.1.LTS_linux-x64_installer.bin"

SRC_URI[sha256sum] = "a7b34001e30f60c5dba219dca45f531512ee390b0946ad862df2d291ccea395f"
