FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-allow-a-device-node-as-a-parameter.patch"

