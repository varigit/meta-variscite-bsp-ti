require sysconfig-cross.inc

SYSCONFIG_BIN = "sysconfig-1.23.0_4000-setup.run"

SRC_URI[sha256sum] = "e50b3fec2caf0463e4d7ae09b68f8641ba498a8bec28efb188a072bc80dfca6f"
